# Keil uVision project GestureScreen.uvprojx, settings and files
target GestureScreen (6240000::V6.24::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(168000000) FPU2 CPUTYPE("Cortex-M4")
  output: GestureScreen +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,GS_STATIC_USE_CUBEAI=1
  c misc: -std=c99 -Wall -Wextra
  c include: ../BSP/Inc;../Middlewares/Third_Party/LwIP/gs_port;../Middlewares/Third_Party/LwIP/src/include;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../App/Inc;../Modules/Camera/Inc;../Modules/Display/Inc;../Modules/Gesture/Inc;../Modules/Ui/Inc;../Modules/Vision/Inc;../Modules/Preview/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Modules/UsbCapture/Inc;../Modules/StaticRecognition/Inc;../Middlewares/ST/AI/Inc;../Middlewares/ST/AI/Generated;../Modules/Content/Inc
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\GestureScreen.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dcmi.c dma.c eth.c fmc.c i2c.c iwdg.c ltdc.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_eth.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group GestureScreen/App
    ../App/Src/: gs_app.c gs_timing_trace.c
  group GestureScreen/BSP
    ../BSP/Src/: gs_debug.c gs_ethernet.c gs_port_board.c gs_usb_capture.c
  group GestureScreen/Camera
    ../Modules/Camera/Src/: gs_camera_pool.c
  group GestureScreen/Content
    ../Modules/Content/Src/: gs_content.c gs_content_builtin.c
  group GestureScreen/Display
    ../Modules/Display/Src/: gs_display_swap.c
  group GestureScreen/Gesture
    ../Modules/Gesture/Src/: gs_gesture.c
  group GestureScreen/Preview
    ../Modules/Preview/Src/: gs_preview.c
  group GestureScreen/StaticRecognition
    ../Modules/StaticRecognition/Src/: gs_cubeai_backend.c gs_static_recognition.c
  group GestureScreen/Ui
    ../Modules/Ui/Src/: gs_ui.c gs_ui_render.c
  group GestureScreen/UsbCapture
    ../Modules/UsbCapture/Src/: gs_usb_protocol.c
  group GestureScreen/Vision
    ../Modules/Vision/Src/: gs_ai.c gs_ai_int8_backend.c gs_model_selected.c gs_preprocess.c
  group GestureScreen/STM32CubeAI
    ../Middlewares/ST/AI/Generated/: gs_network.c gs_network_data.c
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1201_CM4_Keil.lib
  group GestureScreen/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
software components: CMSIS:CORE 4.3.0
